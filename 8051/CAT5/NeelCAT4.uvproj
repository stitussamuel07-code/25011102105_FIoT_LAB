# Keil uVision project NeelCAT4.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: NeelCAT4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: cat4.c
