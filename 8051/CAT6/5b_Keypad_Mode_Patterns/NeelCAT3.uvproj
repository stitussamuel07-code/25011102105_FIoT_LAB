# Keil uVision project NeelCAT3.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: NeelCAT3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: cat3.c
